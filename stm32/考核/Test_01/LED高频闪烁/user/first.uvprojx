# Keil uVision project first.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: first +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\user;..\CORE;..\STM32_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\Systick;..\HARDWARE\usart3;..\HARDWARE\PWM;..\HARDWARE\keypad
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group lib
    ../STM32_FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c
  group user
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group hardware
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/Systick/: systick.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/keypad/: keypad.c keypad.h
